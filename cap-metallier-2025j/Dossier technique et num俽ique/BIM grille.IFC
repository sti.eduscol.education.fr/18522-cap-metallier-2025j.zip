Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Grille.IFC
Time: 2023-11-16T08:38:20
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
